# Keil uVision project atk_h7r7.uvprojx, settings and files
target atk_h7r7 (6220000::V6.22::ARMCLANG)
  device: STM32H7R7L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h7r7 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7R7xx
  c misc: -Wno-invalid-source-encoding -Wno-deprecated-non-prototype
  c include: ..\..\Drivers;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include;..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc;..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc\Legacy;..\..\Middlewares;..\..\User;..\..\Middlewares\USB\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\USB\STM32_USB_Device_Library\Class\CDC\Inc;..\..\Middlewares\USB\USB_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\User\Script\ATK-DNH7R7_flash_ROMxspi1.sct
  link misc: --diag_suppress L6314,L6329
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7r7xx.s
  group User
    ../../User/: main.c stm32h7rsxx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_sram.c stm32h7rsxx_ll_fmc.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_ltdc_ex.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_ll_usb.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c ltdc.c
    ../../Drivers/BSP/HYPERRAM/: hyperram.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/USB_CORE
    ../../Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewars/USB_CLASS
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewars/USB_APP
    ../../Middlewares/USB/USB_APP/: usbd_conf.c usbd_desc.c usbd_cdc_if.c
  group Readme
    ../../: readme.txt
